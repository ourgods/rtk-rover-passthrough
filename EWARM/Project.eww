<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Base_station_V10.ewp</path>
  </project>
  <batchBuild />
</workspace>
